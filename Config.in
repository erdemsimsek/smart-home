## package/hdc3022_app/Config.in
```kconfig
config BR2_PACKAGE_HDC3022_APP
	bool "HDC3022_APP"
	help
	 Application layer driver for HD3022 temperature and humidity driver
```
